# Keil uVision project STM32_DEMO_PRJ.uvproj, settings and files
target STM32_DEMO_PRJ (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_DEMO_PRJ +hex
  AfterMake: fromelf.exe --bin -o ..\Output\STM32_DEMO_PRJ.bin ..\Output\STM32_DEMO_PRJ.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\CMSIS\CoreSupport;..\..\Libraries\CMSIS\DeviceSupport;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\APP;..\..\BSP\bsp;..\..\BSP\systick;..\..\BSP\usart1;..\..\BSP\led;..\..\BSP\timer2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ../../Libraries/CMSIS/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../../Libraries/CMSIS/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Libraries
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c
  group BSP
    ../../BSP/bsp/: bsp.c
    ../../BSP/systick/: systick.c
    ../../BSP/usart1/: usart1.c
    ../../BSP/led/: led.c
    ../../BSP/timer2/: timer2.c
  group APP
    ../../APP/: main.c includes.h define.h sizes.h
